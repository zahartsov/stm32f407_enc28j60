# IAR project ethernet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: .\headers; ..\headers; .\freeRTOS; ..\freeRTOS; .\freeRTOS\include; ..\freeRTOS\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ethernet.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    source/: configuration.c enc28j60.c gpio.c iwdg.c main.c net.c rtc.c sleepmode.c spi.c system.c tim.c
  group CMSIS
    source/CMSIS/: system_stm32f4xx.c
  group freeRTOS
    source/freeRTOS/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group freeRTOS/include
    source/freeRTOS/include/: croutine.h deprecated_definitions.h dma.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_prototypes.h mpu_wrappers.h portable.h portasm.s portmacro.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group headers
    source/headers/: configuration.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h enc28j60.h gpio.h iwdg.h net.h rtc.h sleepmode.h spi.h stm32f4xx.h system.h system_stm32f4xx.h tim.h
  group startup
    source/startup/: startup_stm32f40xx.s
